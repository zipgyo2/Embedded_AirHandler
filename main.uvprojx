# Keil uVision project main.uvprojx, settings and files
target AirHandler (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Huins_NXP_LPC1768_Library\Drivers\include;C:\Keil_v5\ARM\INC\NXP\LPC17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Main
    ./: main.c
  group New Group
    ../Huins_NXP_LPC1768_Library/Drivers/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_clkpwr.c lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_timer.c lpc17xx_uart.c LPC1768_fnd.c LPC1768_motor.c LPC1768_utility.c
software components: Device:Startup 1.0.0
